# Keil uVision project ld3320.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F60XE Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ld3320 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./app/: main.c LDChip.c Reg_RW.c usart.c
